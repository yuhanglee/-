# Keil uVision project 光融合.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: OTG +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source;..\Source\driver;..\Source\system
  group SysDri
    ./: STARTUP.A51
    ../Source/system/: uart.c timer.c WDT.c
  group PerDri
    ../Source/driver/: max485.c led.c
  group App
    ../Source/: main.c botp.c crc.c
